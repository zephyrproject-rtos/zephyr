/*
 * Copyright (c) 2026 Mike Kasprzak (distraction.engineer)
 *
 * SPDX-License-Identifier: Apache-2.0
 */

#include <wch/qingke/v3c.dtsi>
#include "ch5xx.dtsi"
#include <mem.h>

&sram1 {
	reg = <0>
};

&dataflash {
	reg = <DT_SIZE_K(8)>;
};

&bootloader {
	reg = <0>
};
